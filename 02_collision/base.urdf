Commit message: ローラーまでできた

File: 02_collision/base.urdf (robot description, URDF)
Before this commit: robot Base, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=1 1 0.01; visual box size=1 1 0.01
